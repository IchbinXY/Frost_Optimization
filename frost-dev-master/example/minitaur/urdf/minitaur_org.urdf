Commit message: modified URDF file

File: frost-dev-master/example/minitaur/urdf/minitaur_org.urdf (robot description, URDF)
Before this commit: robot minitaur, 17 links, 16 joints
Links:
- link base_chassis_link: mass 5.872 -> 6.0
